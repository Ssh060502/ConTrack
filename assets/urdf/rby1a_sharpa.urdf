Commit message: modify rby1a_sharpa urdf

File: assets/urdf/rby1a_sharpa.urdf (robot description, URDF)
Before this commit: robot RBY1_A_v1.2, 92 links, 91 joints
Joints:
- joint left_wheel: limit velocity=15.707963268 -> (none)
- joint right_wheel: limit velocity=15.707963268 -> (none)
